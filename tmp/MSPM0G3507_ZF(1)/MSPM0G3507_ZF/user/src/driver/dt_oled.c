#include "driver/dt_oled.h"

#define DT_OLED_CMD  0x00
#define DT_OLED_DATA 0x40

static const uint8_t font_6x8[][6] = {
    {0x00,0x00,0x00,0x00,0x00,0x00},
    {0x00,0x00,0x5F,0x00,0x00,0x00},
    {0x00,0x07,0x00,0x07,0x00,0x00},
    {0x14,0x7F,0x14,0x7F,0x14,0x00},
    {0x24,0x2A,0x7F,0x2A,0x12,0x00},
    {0x23,0x13,0x08,0x64,0x62,0x00},
    {0x36,0x49,0x55,0x22,0x50,0x00},
    {0x00,0x05,0x03,0x00,0x00,0x00},
    {0x00,0x1C,0x22,0x41,0x00,0x00},
    {0x00,0x41,0x22,0x1C,0x00,0x00},
    {0x08,0x2A,0x1C,0x2A,0x08,0x00},
    {0x08,0x08,0x3E,0x08,0x08,0x00},
    {0x00,0x50,0x30,0x00,0x00,0x00},
    {0x08,0x08,0x08,0x08,0x08,0x00},
    {0x00,0x60,0x60,0x00,0x00,0x00},
    {0x20,0x10,0x08,0x04,0x02,0x00},
    {0x3E,0x51,0x49,0x45,0x3E,0x00},
    {0x00,0x42,0x7F,0x40,0x00,0x00},
    {0x42,0x61,0x51,0x49,0x46,0x00},
    {0x21,0x41,0x45,0x4B,0x31,0x00},
    {0x18,0x14,0x12,0x7F,0x10,0x00},
    {0x27,0x45,0x45,0x45,0x39,0x00},
    {0x3C,0x4A,0x49,0x49,0x30,0x00},
    {0x01,0x71,0x09,0x05,0x03,0x00},
    {0x36,0x49,0x49,0x49,0x36,0x00},
    {0x06,0x49,0x49,0x29,0x1E,0x00},
    {0x00,0x36,0x36,0x00,0x00,0x00},
    {0x00,0x56,0x36,0x00,0x00,0x00},
    {0x00,0x08,0x14,0x22,0x41,0x00},
    {0x14,0x14,0x14,0x14,0x14,0x00},
    {0x41,0x22,0x14,0x08,0x00,0x00},
    {0x02,0x01,0x51,0x09,0x06,0x00},
    {0x32,0x49,0x79,0x41,0x3E,0x00},
    {0x7E,0x11,0x11,0x11,0x7E,0x00},
    {0x7F,0x49,0x49,0x49,0x36,0x00},
    {0x3E,0x41,0x41,0x41,0x22,0x00},
    {0x7F,0x41,0x41,0x22,0x1C,0x00},
    {0x7F,0x49,0x49,0x49,0x41,0x00},
    {0x7F,0x09,0x09,0x01,0x01,0x00},
    {0x3E,0x41,0x41,0x51,0x32,0x00},
    {0x7F,0x08,0x08,0x08,0x7F,0x00},
    {0x00,0x41,0x7F,0x41,0x00,0x00},
    {0x20,0x40,0x41,0x3F,0x01,0x00},
    {0x7F,0x08,0x14,0x22,0x41,0x00},
    {0x7F,0x40,0x40,0x40,0x40,0x00},
    {0x7F,0x02,0x04,0x02,0x7F,0x00},
    {0x7F,0x04,0x08,0x10,0x7F,0x00},
    {0x3E,0x41,0x41,0x41,0x3E,0x00},
    {0x7F,0x09,0x09,0x09,0x06,0x00},
    {0x3E,0x41,0x51,0x21,0x5E,0x00},
    {0x7F,0x09,0x19,0x29,0x46,0x00},
    {0x46,0x49,0x49,0x49,0x31,0x00},
    {0x01,0x01,0x7F,0x01,0x01,0x00},
    {0x3F,0x40,0x40,0x40,0x3F,0x00},
    {0x1F,0x20,0x40,0x20,0x1F,0x00},
    {0x7F,0x20,0x18,0x20,0x7F,0x00},
    {0x63,0x14,0x08,0x14,0x63,0x00},
    {0x03,0x04,0x78,0x04,0x03,0x00},
    {0x61,0x51,0x49,0x45,0x43,0x00},
    {0x00,0x00,0x7F,0x41,0x41,0x00},
    {0x02,0x04,0x08,0x10,0x20,0x00},
    {0x41,0x41,0x7F,0x00,0x00,0x00},
    {0x04,0x02,0x01,0x02,0x04,0x00},
    {0x40,0x40,0x40,0x40,0x40,0x00},
    {0x00,0x01,0x02,0x04,0x00,0x00},
    {0x20,0x54,0x54,0x54,0x78,0x00},
    {0x7F,0x48,0x44,0x44,0x38,0x00},
    {0x38,0x44,0x44,0x44,0x20,0x00},
    {0x38,0x44,0x44,0x48,0x7F,0x00},
    {0x38,0x54,0x54,0x54,0x18,0x00},
    {0x08,0x7E,0x09,0x01,0x02,0x00},
    {0x08,0x14,0x54,0x54,0x3C,0x00},
    {0x7F,0x08,0x04,0x04,0x78,0x00},
    {0x00,0x44,0x7D,0x40,0x00,0x00},
    {0x20,0x40,0x44,0x3D,0x00,0x00},
    {0x00,0x7F,0x10,0x28,0x44,0x00},
    {0x00,0x41,0x7F,0x40,0x00,0x00},
    {0x7C,0x04,0x18,0x04,0x78,0x00},
    {0x7C,0x08,0x04,0x04,0x78,0x00},
    {0x38,0x44,0x44,0x44,0x38,0x00},
    {0x7C,0x14,0x14,0x14,0x08,0x00},
    {0x08,0x14,0x14,0x18,0x7C,0x00},
    {0x7C,0x08,0x04,0x04,0x08,0x00},
    {0x48,0x54,0x54,0x54,0x20,0x00},
    {0x04,0x3F,0x44,0x40,0x20,0x00},
    {0x3C,0x40,0x40,0x20,0x7C,0x00},
    {0x1C,0x20,0x40,0x20,0x1C,0x00},
    {0x3C,0x40,0x30,0x40,0x3C,0x00},
    {0x44,0x28,0x10,0x28,0x44,0x00},
    {0x0C,0x50,0x50,0x50,0x3C,0x00},
    {0x44,0x64,0x54,0x4C,0x44,0x00},
    {0x00,0x08,0x36,0x41,0x00,0x00},
    {0x00,0x00,0x7F,0x00,0x00,0x00},
    {0x00,0x41,0x36,0x08,0x00,0x00},
    {0x08,0x04,0x08,0x10,0x08,0x00},
};

static void dt_oled_write_cmd(dt_oled_config_t *cfg, uint8_t cmd)
{
    uint8_t buf[2] = { DT_OLED_CMD, cmd };
    soft_iic_write_8bit_array(&cfg->iic, buf, 2);
}

static void dt_oled_write_data(dt_oled_config_t *cfg, uint8_t dat)
{
    uint8_t buf[2] = { DT_OLED_DATA, dat };
    soft_iic_write_8bit_array(&cfg->iic, buf, 2);
}

void dt_oled_init(dt_oled_config_t *cfg)
{
    system_delay_ms(100);

    dt_oled_write_cmd(cfg, 0xAE);
    dt_oled_write_cmd(cfg, 0xD5);
    dt_oled_write_cmd(cfg, 0x80);
    dt_oled_write_cmd(cfg, 0xA8);
    dt_oled_write_cmd(cfg, 0x3F);
    dt_oled_write_cmd(cfg, 0xD3);
    dt_oled_write_cmd(cfg, 0x00);
    dt_oled_write_cmd(cfg, 0x40);
    dt_oled_write_cmd(cfg, 0x8D);
    dt_oled_write_cmd(cfg, 0x14);
    dt_oled_write_cmd(cfg, 0x20);
    dt_oled_write_cmd(cfg, 0x00);
    dt_oled_write_cmd(cfg, 0xA1);
    dt_oled_write_cmd(cfg, 0xC8);
    dt_oled_write_cmd(cfg, 0xDA);
    dt_oled_write_cmd(cfg, 0x12);
    dt_oled_write_cmd(cfg, 0x81);
    dt_oled_write_cmd(cfg, 0xCF);
    dt_oled_write_cmd(cfg, 0xD9);
    dt_oled_write_cmd(cfg, 0xF1);
    dt_oled_write_cmd(cfg, 0xDB);
    dt_oled_write_cmd(cfg, 0x40);
    dt_oled_write_cmd(cfg, 0xA4);
    dt_oled_write_cmd(cfg, 0xA6);
    dt_oled_write_cmd(cfg, 0xAF);
}

void dt_oled_set_pos(dt_oled_config_t *cfg, uint8_t x, uint8_t y)
{
    dt_oled_write_cmd(cfg, 0xB0 + y);
    dt_oled_write_cmd(cfg, ((x & 0xF0) >> 4) | 0x10);
    dt_oled_write_cmd(cfg, (x & 0x0F));
}

void dt_oled_clear(dt_oled_config_t *cfg)
{
    uint8_t i, j;
    for (i = 0; i < DT_OLED_PAGE_COUNT; i++)
    {
        dt_oled_set_pos(cfg, 0, i);
        for (j = 0; j < DT_OLED_WIDTH; j++)
        {
            dt_oled_write_data(cfg, 0x00);
        }
    }
}

void dt_oled_fill(dt_oled_config_t *cfg, uint8_t data)
{
    uint8_t i, j;
    for (i = 0; i < DT_OLED_PAGE_COUNT; i++)
    {
        dt_oled_set_pos(cfg, 0, i);
        for (j = 0; j < DT_OLED_WIDTH; j++)
        {
            dt_oled_write_data(cfg, data);
        }
    }
}

void dt_oled_show_char(dt_oled_config_t *cfg, uint8_t x, uint8_t y, char ch)
{
    uint8_t i;
    dt_oled_set_pos(cfg, x, y);
    for (i = 0; i < 6; i++)
    {
        if (ch >= ' ' && ch <= '~')
        {
            dt_oled_write_data(cfg, font_6x8[ch - ' '][i]);
        }
        else
        {
            dt_oled_write_data(cfg, 0x00);
        }
    }
}

void dt_oled_show_string(dt_oled_config_t *cfg, uint8_t x, uint8_t y, const char *str)
{
    while (*str)
    {
        dt_oled_show_char(cfg, x, y, *str);
        x += 6;
        if (x > DT_OLED_WIDTH - 6)
        {
            x = 0;
            y++;
        }
        str++;
    }
}

void dt_oled_show_num(dt_oled_config_t *cfg, uint8_t x, uint8_t y, int32_t num, uint8_t len)
{
    char buf[12];
    uint8_t i;
    uint8_t start = 0;
    if (num < 0)
    {
        buf[0] = '-';
        num = -num;
        start = 1;
    }
    for (i = 0; i < len; i++)
    {
        buf[len - 1 - i + start] = '0' + (uint8_t)(num % 10);
        num /= 10;
    }
    buf[len + start] = '\0';
    dt_oled_show_string(cfg, x, y, buf);
}

void dt_oled_show_hex(dt_oled_config_t *cfg, uint8_t x, uint8_t y, uint32_t num, uint8_t len)
{
    char buf[12];
    const char hex[] = "0123456789ABCDEF";
    uint8_t i;
    for (i = 0; i < len; i++)
    {
        buf[len - 1 - i] = hex[num & 0x0F];
        num >>= 4;
    }
    buf[len] = '\0';
    dt_oled_show_string(cfg, x, y, buf);
}

void dt_oled_show_float(dt_oled_config_t *cfg, uint8_t x, uint8_t y, float num, uint8_t int_len, uint8_t dec_len)
{
    int32_t int_part;
    uint32_t dec_part;
    uint32_t pow10 = 1;
    uint8_t i;

    if (num < 0)
    {
        dt_oled_show_char(cfg, x, y, '-');
        x += 6;
        num = -num;
    }

    for (i = 0; i < dec_len; i++) pow10 *= 10;

    int_part = (int32_t)num;
    dec_part = (uint32_t)((num - (float)int_part) * (float)pow10 + 0.5f);
    if (dec_part >= pow10) { int_part++; dec_part = 0; }

    dt_oled_show_num(cfg, x, y, int_part, int_len);
    x += int_len * 6;
    dt_oled_show_char(cfg, x, y, '.');
    x += 6;
    dt_oled_show_num(cfg, x, y, (int32_t)dec_part, dec_len);
}
